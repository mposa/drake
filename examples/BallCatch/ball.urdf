Commit message: Working commits.

File: examples/BallCatch/ball.urdf (robot description, URDF)
Before this commit: robot Ball, 10 links, 9 joints
Links:
- link ball_1: mass 4 -> 1
- link ball_2: geometry visual sphere radius=0.1
- link ball_3: geometry visual sphere radius=0.1
